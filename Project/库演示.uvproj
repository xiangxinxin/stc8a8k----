# Keil uVision project 库演示.uvproj, settings and files
target 库演示 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: LIB_demo +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group USER
    ../User/: main.c soft_uart.c multi_key.c key.c multi_tim.c
